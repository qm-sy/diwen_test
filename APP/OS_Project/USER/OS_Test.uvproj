# Keil uVision project OS_Test.uvproj, settings and files
target Target 1 (MCS-51)
  device: T5 DWIN
  cpu: IRAM(0-0xFF) CLOCK(24000000) MODC2 PMW DPC BSE MDU_R515
  output: OS_Test +hex
  c flags: Optimize=3
  c include: ..\USER;..\HANDWARE
  link misc: REMOVEUNUSED
  group USER
    ./: main.c STARTUP_M5.A51 sys.c
  group HANDWARE
    ../HANDWARE/: uart.c
